# Keil uVision project YS-V0.7.uvproj, settings and files
target YS-V0.7 普通模式工程 (MCS-51)
  device: STC10F12XE STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(45000000) MODP2
  output: V07B +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code;..\user
  group APP
    ../code/: main.c LDChip.c Reg_RW.c
    ./: nrf.c
  group Driver
    ../user/: usart.c
